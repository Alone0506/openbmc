FILESEXTRAPATHS:prepend := "${THISDIR}:"

SRC_URI = "file://sdbusplus"
S = "${UNPACKDIR}/sdbusplus/tools"
