inherit externalsrc
EXTERNALSRC = "/media/g2/openbmc/bmcweb"