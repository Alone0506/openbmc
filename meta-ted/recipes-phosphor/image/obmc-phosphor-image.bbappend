OBMC_IMAGE_EXTRA_INSTALL:append:romulus = " ipmitool"