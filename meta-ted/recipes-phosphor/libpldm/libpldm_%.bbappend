# The local PLDM checkout requires the GetTID response API added in v0.17.0.
SRCREV = "6ea218c28b3bedfe6bdb19a09964c59ac7839d6b"
